Commit message: split ball and paddle

File: ball_and_table.urdf (robot description, URDF)
Before this commit: robot BallAndPaddle, 5 links, 3 joints
Links:
- removed link paddle_handle
- removed link paddle_head
Joints:
- removed joint paddle_fixed
